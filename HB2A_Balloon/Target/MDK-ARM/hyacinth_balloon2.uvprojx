# Keil uVision project hyacinth_balloon2.uvprojx, settings and files
target hyacinth_balloon2 (6240000::V6.24::ARMCLANG)
  device: STM32U575RGTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: hyacinth_balloon2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,BME280_64BIT_ENABLE,BME280_PRESSURE_UNCLAMPED
  c include: ../../App/Inc;../Drivers/ThirdParty/BME280;../Drivers/ThirdParty/INA3221;../Drivers/ThirdParty/INA3221/port;../Core/Inc;..\Core\Inc\camera;../Drivers/BSP/Components/ov5640;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c i2c.c spi.c usart.c si5351.c u4b_telemetry.c ubx.c wspr_enc.c sensors.c sensor_format.c aprs.c ax25_afsk.c sx1278_aprs.c uplink_protocol.c gmsk_downlink.c high_speed_ssdv.c flash_selftest.c image_storage.c ssdv.c rs8.c factory_image.c stm32u5xx_it.c stm32u5xx_hal_msp.c
    ../../App/Src/: app_main.c app_flow.c gnss_service.c telemetry_service.c aprs_service.c aprs_schedule_service.c wspr_service.c wspr_radio_service.c startup_selftest_service.c transponder_service.c high_speed_service.c camera_ssdv_service.c
    ../Drivers/ThirdParty/BME280/: bme280.c
    ../Drivers/ThirdParty/INA3221/: ina3221.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_dcmi.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Camera
    ../Core/Src/: camera.c
    ../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
software components: CMSIS:CORE 5.6.0
